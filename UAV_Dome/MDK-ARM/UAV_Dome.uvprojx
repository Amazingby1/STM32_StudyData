# Keil uVision project UAV_Dome.uvprojx, settings and files
target UAV_Dome (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: UAV_Dome +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7B0xx,__FPU_PRESENT=1,ARM_MATH_CM7,__CC_ARM
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Drivers/CMSIS/DSP/Include;../Hardware/BSP;../Hardware/Devices/TFTLCD;../Hardware/OLED;../System;../Hardware/MPU6050;../Hardware/MS5611;../DSP_FFT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group Application/MDK-ARM
    ./: startup_stm32h7b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group DSP_FFT
    ../DSP_FFT/: arm_cortexM7l_math.lib arm_fft_bin_data.c FFT_Handle.c FFT_Handle.h
  group Hardware
    ../Hardware/Devices/TFTLCD/: tftlcd.c
    ../Hardware/BSP/: BSP_SPI.c
    ../Hardware/OLED/: OLED.c OLED.h OLED_Font.h
    ../Hardware/MPU6050/: Bsp_MPU6050.c Bsp_MyIIC.c Bsp_MyIIC.h Bsp_MPU6050.h
    ../Hardware/MS5611/: Bsp_MS5611.h Bsp_MS5611.c MS5611_IIC.c MS5611_IIC.h
  group System
    ../System/: Motor_PID.c Motor_PID.h Delay.c Delay.h Interrupt_Handle.c
software components: CMSIS:CORE 5.0.1
